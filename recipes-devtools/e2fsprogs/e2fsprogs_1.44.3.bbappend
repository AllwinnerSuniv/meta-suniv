SRC_URI = "git://github.com/AllwinnerSuniv/e2fsprogs.git"